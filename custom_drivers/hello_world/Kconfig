## custom_drivers/hello_world/Kconfig
```kconfig
menu "maherme custom modules"
    config CUSTOM_HELLOWORLD
        tristate "helloworld module support"
        default n
endmenu
```
